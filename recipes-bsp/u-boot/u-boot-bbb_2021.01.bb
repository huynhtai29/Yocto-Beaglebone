require u-boot-src.inc

UBOOT_MACHINE_NAME = "beaglebone_black"
UBOOT_MACHINE = "am335x_boneblack_vboot_defconfig"
